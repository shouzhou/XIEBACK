# Keil uVision project price_scale_Vc.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: price_scale_Vc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./_solidic/: STARTUP_SOLIDIC_Vc_5219_Jan10_13.A51
    ./_adc/: adc_0819_Vc_Jan10_13.c
    ./_data_nvm/: data_nvm_5219_Vc_Dec09_13.c
    ./_dsp_driver/: display_driver_Vc_Mar18_13.c
    ./customer/: display_cal.c keyboard.c main.c
    ./: ext_weight_cal.obj filter_cal_Vc_Jul19_14(filter-1).obj
